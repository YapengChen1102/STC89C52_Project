# Keil uVision project 实验3-1 CT107D实验板.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 实验3-1 CT107D实验板 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: CT107D_main.c CT107D_Lib.c CT107D_Lib.h
